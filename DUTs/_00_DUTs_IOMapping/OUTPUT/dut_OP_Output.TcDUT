TYPE dut_OP_Output :
STRUCT
	










END_STRUCT
END_TYPE
