TYPE dut_EX260_SEC :
STRUCT
	A:dut_USINT_BOOL;
	B:dut_USINT_BOOL;
	C:dut_USINT_BOOL;
	D:dut_USINT_BOOL;
END_STRUCT
END_TYPE
