TYPE dut_8Bits :
STRUCT
	v1 ,
	v2 ,
	v3 ,
	v4 ,
	v5 ,
	v6 ,
	v7 ,
	v8 
	:BIT;
END_STRUCT
END_TYPE
