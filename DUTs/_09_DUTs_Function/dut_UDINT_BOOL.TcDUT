TYPE dut_UDINT_BOOL :
UNION
	Data_UDINT	:UDINT;
	Data_Bit	:dut_32Bits;
END_UNION
END_TYPE
