TYPE dut_USINT_BOOL :
UNION
	uUSINT 	: USINT;
	uBit  	: dut_8Bits;
END_UNION
END_TYPE
