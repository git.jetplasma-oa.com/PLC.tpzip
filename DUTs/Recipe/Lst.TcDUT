TYPE Lst :
STRUCT
	Pressure:LstPressure;
	GAS:LstGas;
	Heater:LstHeater;
END_STRUCT
END_TYPE
