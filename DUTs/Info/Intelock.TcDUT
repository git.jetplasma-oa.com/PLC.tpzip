TYPE Intelock :
STRUCT	
	ForelinePressure:BOOL;
END_STRUCT
END_TYPE
