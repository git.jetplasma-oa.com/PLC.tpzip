TYPE SVINT :
STRUCT
	MinSV:INT;
	MaxSV:INT;
	PV:INT;
	SV:INT;
END_STRUCT
END_TYPE
