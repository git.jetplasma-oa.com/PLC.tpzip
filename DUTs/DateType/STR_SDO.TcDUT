TYPE STR_SDO :
STRUCT
	Index				:UINT;;		
	Subindex			:USINT;		
	IsCompleteAccess 	:BOOL;	
END_STRUCT
END_TYPE
