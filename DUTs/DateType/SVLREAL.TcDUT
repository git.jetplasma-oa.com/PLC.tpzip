TYPE SVLREAL :
STRUCT
	MinSV:LREAL;
	MaxSV:LREAL;
	PV:LREAL;
	SV:LREAL;
END_STRUCT
END_TYPE
