TYPE STR_PID :
STRUCT
	P,
	I,
	D,
	DP,
	Feedforward,
	Output_Limit:REAL;
END_STRUCT
END_TYPE
