TYPE ConfigDryPump :
STRUCT
	ChamberForlinePressureTolerance:SVLREAL;
	ChamberForlinePressureTimeout:SVINT;
END_STRUCT
END_TYPE
