TYPE ConfigDryPump :
STRUCT
	MFG:SVINT;
	CommType:SVINT;
	Port:STRING;
	ChamberForlinePressureTolerance:SVLREAL;
	ChamberForlinePressureTimeout:SVINT;
END_STRUCT
END_TYPE
