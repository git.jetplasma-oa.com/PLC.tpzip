TYPE ConfigEPD :
STRUCT
	IsEnabled:BOOL;
	ChannelNumber:SVINT;
	IPAdress:STRING;
	EPDType:SVINT;
END_STRUCT
END_TYPE
