TYPE ConfigIdleClean :
STRUCT
	Option:SVINT;
	
	IdleCleanRecipe:STRING;
	IdleCleanTime:SVINT;
	IdleCleanWaferCount:SVINT;
	
	WaferCountSinceLastClean:SVINT;
	LastRunTime:STRING;
END_STRUCT
END_TYPE
