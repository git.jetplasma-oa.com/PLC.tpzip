TYPE ConfigTurboPump :
STRUCT
	Port:STRING;
	ChamberForelinePressureThreshold:SVLREAL;
	ChamberForelinePressureTimeout:SVINT;
END_STRUCT
END_TYPE
