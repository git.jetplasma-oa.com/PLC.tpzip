TYPE ConfigElectrostaticVoltageSource :
STRUCT
	Port:STRING;
END_STRUCT
END_TYPE
