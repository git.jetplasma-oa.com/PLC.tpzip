TYPE ConfigPendulumValve :
STRUCT
	Port:STRING;
	PressureFullRange:SVINT;
	ForelinePressureLimit:SVINT;
	ChamberPressureLimit:SVINT;
	TurboPumpSpeedLimit:SVINT;
END_STRUCT
END_TYPE
