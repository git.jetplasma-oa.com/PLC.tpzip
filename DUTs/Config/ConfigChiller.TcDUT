TYPE ConfigChiller :
STRUCT
	Enable:BOOL;
	MaxLimit:SVLREAL;
	MinLimit:SVLREAL;
	EnableAlarmTolerance:BOOL;
	ToleranceAlarmRange:SVINT;
	ToleranceAlarmTime:SVINT;
END_STRUCT
END_TYPE
