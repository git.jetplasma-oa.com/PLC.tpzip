TYPE STR_FCSP700_OUTPUT :
STRUCT
	Flow_SP					:	REAL	;
	Actuator_Control		:	USINT	;
	Actuator_Position_SP	:	REAL	;
	Ramp_Time				:	UDINT	;
END_STRUCT
END_TYPE
