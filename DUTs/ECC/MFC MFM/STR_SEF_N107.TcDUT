TYPE STR_SEF_N107 :
STRUCT
	Input0_Active_Exception_Status_F380_00		:	USINT	;
	Input0_Flow_Reading_6000_01					:	REAL	;
END_STRUCT
END_TYPE
