TYPE APC_Controller :
STRUCT
	P	:	REAL	;
	I	:	REAL	;
	D	:	REAL	;
	a	:	REAL	;
	CH	:	REAL	;
	CL	:	REAL	;
	OFFSET	:	REAL	;

END_STRUCT
END_TYPE
