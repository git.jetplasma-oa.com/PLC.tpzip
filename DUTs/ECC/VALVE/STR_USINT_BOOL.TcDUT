TYPE STR_USINT_BOOL :
UNION
	T_USINT:USINT;
	T_BOOL:ARRAY [1..8] OF BOOL;
END_UNION
END_TYPE
