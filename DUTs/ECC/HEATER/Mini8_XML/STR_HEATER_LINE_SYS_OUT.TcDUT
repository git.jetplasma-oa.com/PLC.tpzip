TYPE STR_HEATER_LINE_SYS_OUT :
STRUCT
	SP	:	REAL	;
	Clear_Alarms	:	UINT	;
	Forced_MV	:	REAL	;
	Auto_Manual	:	BIT	;
	Inhibit	:	BIT	;
END_STRUCT
END_TYPE
