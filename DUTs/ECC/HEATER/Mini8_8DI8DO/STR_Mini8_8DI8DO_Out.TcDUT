TYPE STR_Mini8_8DI8DO_Out :
STRUCT
	SYS_Output	:ARRAY[1..8] OF STR_HEATER_LINE_SYS_OUT;
	CUS_Output	:ARRAY[1..8] OF STR_HEATER_LINE_CUS_OUT;
END_STRUCT
END_TYPE
