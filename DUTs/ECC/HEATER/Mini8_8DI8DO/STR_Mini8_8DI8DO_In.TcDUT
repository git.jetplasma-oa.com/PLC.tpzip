TYPE STR_Mini8_8DI8DO_In :
STRUCT
	SYS_Input	:ARRAY[1..8] OF STR_HEATER_LINE_SYS_IN;
	CUS_Input	:ARRAY[1..8] OF STR_HEATER_LINE_CUS_IN;
END_STRUCT
END_TYPE
