TYPE STR_Mini8_16DI16DO_Out :
STRUCT
	SYS_Output	:ARRAY[1..16] OF STR_HEATER_LINE_SYS_OUT;
	CUS_Output	:ARRAY[1..16] OF STR_HEATER_LINE_CUS_OUT;
END_STRUCT
END_TYPE
