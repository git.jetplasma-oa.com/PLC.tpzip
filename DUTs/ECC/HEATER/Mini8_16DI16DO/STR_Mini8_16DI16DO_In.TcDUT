TYPE STR_Mini8_16DI16DO_In :
STRUCT
	SYS_Input	:ARRAY[1..16] OF STR_HEATER_LINE_SYS_IN;
	CUS_Input	:ARRAY[1..16] OF STR_HEATER_LINE_CUS_IN;
END_STRUCT
END_TYPE
