TYPE STR_EL3154 :		//4AI,4-20mA,16bits
STRUCT
	AI1		:INT;
	AI2		:INT;
	AI3		:INT;
	AI4		:INT;
END_STRUCT
END_TYPE
