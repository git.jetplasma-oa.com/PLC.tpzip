TYPE STR_EL3164 :		//4AI,0-10V,16bits
STRUCT
	AI1		:INT;
	AI2		:INT;
	AI3		:INT;
	AI4		:INT;
END_STRUCT
END_TYPE
