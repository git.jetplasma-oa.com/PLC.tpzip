TYPE TMP_OUT :
STRUCT
	Turbo_Start_Stop	:	BIT	;	//	1:START,0:STOP
	Turbo_Reset_Alarm	:	BIT	;	//	1:RESET ALARM,0:NO ACTION
	Turbo_Low_Speed		:	BIT	;	//	1:LOW SPEED MODE ON,0:OFF
END_STRUCT
END_TYPE
