TYPE VG_Data :
STRUCT
	I_Pressure:REAL;
END_STRUCT
END_TYPE
