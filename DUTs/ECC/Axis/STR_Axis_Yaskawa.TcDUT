TYPE STR_Axis_Yaskawa :
STRUCT
	
END_STRUCT
END_TYPE
