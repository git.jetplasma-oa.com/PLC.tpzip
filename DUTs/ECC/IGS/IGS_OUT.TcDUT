TYPE IGS_OUT :
STRUCT
	//C42	EL2889	16DO
	C42	 	:ARRAY [1..16] OF BOOL;
	
	//C43	EL2904	4SDO
	C43		:ARRAY [1..4] OF BOOL;
END_STRUCT
END_TYPE
