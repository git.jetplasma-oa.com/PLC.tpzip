TYPE CHILLER_OUT :
STRUCT
	Module1_Word:ARRAY [1..2] OF UINT;	
	Module2_Word:ARRAY [1..16] OF UINT;
	//Module3_Word:ARRAY [1..16] OF UINT;	
END_STRUCT
END_TYPE
