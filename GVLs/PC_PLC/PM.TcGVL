{attribute 'qualified_only'}
VAR_GLOBAL
	HeartBeat:REAL;
//HW
	NDI:STR_NDI;
	AI:STR_AI;	
//SYSTEM
	Info:Info;
	ProcessFeedBack:ProcessRecipeFeedBack;	
END_VAR
